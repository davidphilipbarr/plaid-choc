# Repository davidphilipbarr/plaid-choc

File README.md:

Plaid-Choc
=================

## As of 8/02/24 this is still untested and should not be used to generate gerbers without due care.

Choc spaced version of Plaid - a 4x12 ortholinear keyboard kit made by through hole components only.

This version supports choc V1 switches only. 

This is forked from an updated version modified to use USB-C instead of Mini USB by piit79.

Atmega328p with VUSB on [QMK firmware](https://github.com/qmk/qmk_firmware).

[Build guide and bom is here](./doc)
[ビルドガイドとパーツリストはこちら](./doc)

## KiCad design pcb/plaid.kicad_pcb

Board: 2 copper layers, 217.5 x 92.1 mm, 130 parts (1 on the bottom side), 78 nets.

Parts:
C1, C2: 20p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3: 4.7u; CP_Radial_D4.0mm_P1.50mm
C4, C5: 100n; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: 1N4148; D_DO-35_SOD27_P5.08mm_Horizontal
D49, D50: 3.6V; D_DO-35_SOD27_P5.08mm_Horizontal
F1: 100mA; polyfuse_5.1mm
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10: M2; MountingHole_2.2mm_M2_Pad
J2: AVR_ISP_6; Pin_Header_Straight_2x03_Pitch2.54mm
J3: Conn_01x04; OLED_v2
R1, R5, R6: 1.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2, R3: 75R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R4: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R7, R8: 5.1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49: SW_Push; choc-v1-with-millmax_edit
SW50: RESET; SW_PUSH_6mm
SW51: BOOT; SW_PUSH_6mm
U1: ATMEGA328-PU; DIP-28_W7.62mm
USB1: USB_C_GCT_USB4085-Type-C; USB_C_GCT_USB4085-offset-pads
Y1: 16MHz; Crystal_HC49-4H_Vertical

Connections:
+5V: C3.1, C4.1, C5.1, F1.2, J2.2, J3.3, R1.2, R4.1, R5.1, R6.1, U1.7 (VCC), U1.20 (AVCC)
/COL0: SW1.2, SW13.2, SW25.2, SW37.2, U1.14 (PB0)
/COL1: SW2.2, SW14.2, SW26.2, SW38.2, U1.13 (PD7)
/COL2: SW3.2, SW15.2, SW27.2, SW39.2, U1.12 (PD6)
/COL3: SW4.2, SW16.2, SW28.2, SW40.2, SW51.1, U1.11 (PD5)
/COL4: SW5.2, SW17.2, SW29.2, SW41.2, U1.16 (PB2)
/COL5: SW6.2, SW18.2, SW30.2, SW42.2, SW49.2, U1.15 (PB1)
/COL6: SW7.2, SW19.2, SW31.2, SW43.2, U1.23 (PC0)
/COL7: SW8.2, SW20.2, SW32.2, SW44.2, U1.24 (PC1)
/COL8: SW9.2, SW21.2, SW33.2, SW45.2, U1.25 (PC2)
/COL9: SW10.2, SW22.2, SW34.2, SW46.2, U1.26 (PC3)
/COL10: SW11.2, SW23.2, SW35.2, SW47.2, U1.3 (PD1)
/COL11: SW12.2, SW24.2, SW36.2, SW48.2, U1.2 (PD0)
/RESET: J2.5, R4.2, SW50.1, U1.1 (~RESET/PC6)
/ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), J2.1, U1.18 (PB4)
/ROW1: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), J2.3, U1.19 (PB5)
/ROW2: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), J2.4, U1.17 (PB3)
/ROW3: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U1.6 (PD4)
/USB_D+: R2.1, U1.4 (PD2)
/USB_D-: R3.1, U1.5 (PD3)
/i2c_SCL: J3.2, R5.2, U1.28 (PC5)
/i2c_SDA: J3.1, R6.2, U1.27 (PC4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D49.2 (A), D50.2 (A), J2.6, J3.4, R7.1, R8.1, SW50.2, SW51.2, U1.8 (GND), U1.22 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.S1 (SHIELD)
unnamed: C1.1, U1.10 (XTAL2/PB7), Y1.2
unnamed: C2.1, U1.9 (XTAL1/PB6), Y1.1
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: D18.2 (A), SW18.1
unnamed: D19.2 (A), SW19.1
unnamed: D20.2 (A), SW20.1
unnamed: D21.2 (A), SW21.1
unnamed: D22.2 (A), SW22.1
unnamed: D23.2 (A), SW23.1
unnamed: D24.2 (A), SW24.1
unnamed: D25.2 (A), SW25.1
unnamed: D26.2 (A), SW26.1
unnamed: D27.2 (A), SW27.1
unnamed: D28.2 (A), SW28.1
unnamed: D29.2 (A), SW29.1
unnamed: D30.2 (A), SW30.1
unnamed: D31.2 (A), SW31.1
unnamed: D32.2 (A), SW32.1
unnamed: D33.2 (A), SW33.1
unnamed: D34.2 (A), SW34.1
unnamed: D35.2 (A), SW35.1
unnamed: D36.2 (A), SW36.1
unnamed: D37.2 (A), SW37.1
unnamed: D38.2 (A), SW38.1
unnamed: D39.2 (A), SW39.1
unnamed: D40.2 (A), SW40.1
unnamed: D41.2 (A), SW41.1
unnamed: D42.2 (A), SW42.1, SW49.1
unnamed: D43.2 (A), SW43.1
unnamed: D44.2 (A), SW44.1
unnamed: D45.2 (A), SW45.1
unnamed: D46.2 (A), SW46.1
unnamed: D47.2 (A), SW47.1
unnamed: D48.2 (A), SW48.1
unnamed: D49.1 (K), R2.2, USB1.A6 (DP1), USB1.B6 (DP2)
unnamed: D50.1 (K), R1.1, R3.2, USB1.A7 (DN1), USB1.B7 (DN2)
unnamed: F1.1, USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
unnamed: R7.2, USB1.A5 (CC1)
unnamed: R8.2, USB1.B5 (CC2)

## Commit log

2024-02-08 remove pcb directory, quicker to replace
2024-02-08 Make key layout choc spaced and re-route
2024-02-08 add kicad image
2024-02-08 properly align the 2x thumb on bottom row
2024-02-08 Actually properly align and place the thumb 2x switch
2024-02-08 update pcb pic

Notices in the files:
pcb/plaid.kicad_pcb:
(c) 2019 Takuya Urakawa, Dm9Records.com
